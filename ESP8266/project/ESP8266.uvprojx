# Keil uVision project ESP8266.uvprojx, settings and files
target SX127xDriver (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: esp8266 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\main;..\STM32F10x_FWLib\inc;..\SX127X;..\CORE;..\device\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group main
    ../main/: stm32f10x_it.c system_stm32f10x.c main.c
    ../STM32F10x_FWLib/src/: stm32f10x_rcc.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_usart.c
  group device
    ../device/src/: delay.c usart.c esp8266.c tcp.c mqtt.c
