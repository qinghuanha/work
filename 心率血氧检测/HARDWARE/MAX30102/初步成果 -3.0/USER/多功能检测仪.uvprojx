# Keil uVision project 多功能检测仪.uvprojx, settings and files
target Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRtos\include;..\FreeRtos\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\MAX30102;..\HARDWARE\i2c;..\HARDWARE\OLED12832;..\SYSTEM\flash
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/flash/: MyFLASH.c MyFLASH.h Store.c Store.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group README
    ../: README.TXT
  group FreeRTOS_CORE
    ../FreeRtos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRtos/portable/RVDS/ARM_CM3/: port.c
    ../FreeRtos/portable/MemMang/: heap_4.c
  group MAX30102
    ../HARDWARE/MAX30102/: algorithm.c blood.c max30102.c max30102_fir.c
  group i2c
    ../HARDWARE/i2c/: i2c.c
  group OLED12832
    ../HARDWARE/OLED12832/: oled12832.c ASCII_8x16.h
